<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>IS620</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>..\51_List\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F4xx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments>-MPU</SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM4</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments>-MPU</TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM4</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=75,107,441,657,0)(1007=105,140,282,408,0)(1008=90,124,456,353,0)(1009=120,156,354,697,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-UV0010M9E -O207 -S0 -C0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO17 -FD20000000 -FC800 -FN1 -FF0STM32F4xx_1024 -FS08000000 -FL080000</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>1351</LineNumber>
          <EnabledFlag>0</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\File_C\NewWork\620NNew\23_FUNC_Monitor\FUNC_DiDo.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>1</Number>
          <Type>0</Type>
          <LineNumber>272</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_IS620P-KS_IS650N_IS650P\IS620N\01_开发库\03_软件\04_代码\20141016\33_COMM_EtherCAT\ECT_ESMDisplay.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>2</Number>
          <Type>0</Type>
          <LineNumber>44</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_IS620P-KS_IS650N_IS650P\IS620N\01_开发库\03_软件\04_代码\20141016\00_Public\PUB_ServoConfiguration.h</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>3</Number>
          <Type>0</Type>
          <LineNumber>992</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_IS620P-KS_IS650N_IS650P\IS620N\01_开发库\03_软件\04_代码\20141016\24_FUNC_ManageFunCode\FUNC_FunCodeDefault.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>4</Number>
          <Type>0</Type>
          <LineNumber>714</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_IS620P-KS_IS650N_IS650P\IS620N\01_开发库\03_软件\04_代码\20141016\24_FUNC_ManageFunCode\FUNC_FunCode.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>5</Number>
          <Type>0</Type>
          <LineNumber>376</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\11_MTR_ReguCtrl\MTR_PostFPGAErr.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>6</Number>
          <Type>0</Type>
          <LineNumber>914</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\11_MTR_ReguCtrl\MTR_HDH_AbsRomOper.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>7</Number>
          <Type>0</Type>
          <LineNumber>101</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\23_FUNC_Monitor\FUNC_AoDriver_ST.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>8</Number>
          <Type>0</Type>
          <LineNumber>219</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\22_FUNC_MotionCtrl\FUNC_PosCtrl.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>9</Number>
          <Type>0</Type>
          <LineNumber>551</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\20_FUNC_System\FUNC_System.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>10</Number>
          <Type>0</Type>
          <LineNumber>473</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\22_FUNC_MotionCtrl\FUNC_PosFbCalc.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
        <Bp>
          <Number>11</Number>
          <Type>0</Type>
          <LineNumber>475</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MC_14_IS620N_20141016\22_FUNC_MotionCtrl\FUNC_PosFbCalc.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
      </Breakpoint>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>STR_MTR_Gvar.OscTarget.CH1_Test,0x0A</ItemText>
        </Ww>
      </WatchWindow1>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>0x8000000</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable>D:\PCLint\Gimpel_PC_Lint_9\DOS-ins\LINT-NT.EXE</LintExecutable>
      <LintConfigFile>D:\PCLint\config\co-kcarm.lnt</LintConfigFile>
      <LintIncludes>
        <Li>
          <IntNumber>0</IntNumber>
          <ItemText>..\00_Public</ItemText>
        </Li>
        <Li>
          <IntNumber>1</IntNumber>
          <ItemText>..\10_MTR_System</ItemText>
        </Li>
        <Li>
          <IntNumber>2</IntNumber>
          <ItemText>..\11_MTR_ReguCtrl</ItemText>
        </Li>
        <Li>
          <IntNumber>3</IntNumber>
          <ItemText>..\12_MTR_Monitor</ItemText>
        </Li>
        <Li>
          <IntNumber>4</IntNumber>
          <ItemText>..\20_FUNC_System</ItemText>
        </Li>
        <Li>
          <IntNumber>5</IntNumber>
          <ItemText>..\21_FUNC_SpdToqCtrl</ItemText>
        </Li>
        <Li>
          <IntNumber>6</IntNumber>
          <ItemText>..\22_FUNC_MotionCtrl</ItemText>
        </Li>
        <Li>
          <IntNumber>7</IntNumber>
          <ItemText>..\23_FUNC_Monitor</ItemText>
        </Li>
        <Li>
          <IntNumber>8</IntNumber>
          <ItemText>..\24_FUNC_ManageFunCode</ItemText>
        </Li>
        <Li>
          <IntNumber>9</IntNumber>
          <ItemText>..\25_FUNC_VibraDamp_SelfTuning</ItemText>
        </Li>
        <Li>
          <IntNumber>10</IntNumber>
          <ItemText>..\30_COMM_Modbus</ItemText>
        </Li>
        <Li>
          <IntNumber>11</IntNumber>
          <ItemText>..\\40_STM32F4xx_Lib\inc</ItemText>
        </Li>
        <Li>
          <IntNumber>12</IntNumber>
          <ItemText>..\13_MTR_AuxFunc</ItemText>
        </Li>
        <Li>
          <IntNumber>13</IntNumber>
          <ItemText>..\10_MTR_Obj</ItemText>
        </Li>
        <Li>
          <IntNumber>14</IntNumber>
          <ItemText>..\22_FUNC_MotionCtrl_Obj</ItemText>
        </Li>
        <Li>
          <IntNumber>15</IntNumber>
          <ItemText>..\23_FUNC_Monitor2</ItemText>
        </Li>
        <Li>
          <IntNumber>16</IntNumber>
          <ItemText>..\32_COMM_CANopen</ItemText>
        </Li>
        <Li>
          <IntNumber>17</IntNumber>
          <ItemText>..\33_COMM_EtherCAT</ItemText>
        </Li>
        <Li>
          <IntNumber>18</IntNumber>
          <ItemText>D:\develop\keil\ARM\RV31\INC</ItemText>
        </Li>
      </LintIncludes>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Startup</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>15</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>52</TopLine>
      <CurrentLine>52</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\startup_stm32f4xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f4xx.s</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>STM32F4xx_Lib</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\misc.c</PathWithFileName>
      <FilenameWithoutPath>misc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_adc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_can.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_can.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_dac.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dac.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_dbgmcu.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dbgmcu.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_dcmi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dcmi.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>39</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>139</TopLine>
      <CurrentLine>139</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_dma2d.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dma2d.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>62</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dma.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_exti.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_flash.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>60</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_fsmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_fsmc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>14</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_gpio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_i2c.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_iwdg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_ltdc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_ltdc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>24</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_pwr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>5</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_rcc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_rng.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_rtc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_sai.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_sai.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_sdio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_sdio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_spi.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_syscfg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_syscfg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>17</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_tim.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>20</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_usart.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\40_STM32F4xx_Lib\src\stm32f4xx_wwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_wwdg.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>00_Public</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>39</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>193</TopLine>
      <CurrentLine>202</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_Main.c</PathWithFileName>
      <FilenameWithoutPath>PUB_Main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>360</TopLine>
      <CurrentLine>375</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_Table.c</PathWithFileName>
      <FilenameWithoutPath>PUB_Table.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>25</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>6</TopLine>
      <CurrentLine>20</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_RCCDriver.c</PathWithFileName>
      <FilenameWithoutPath>PUB_RCCDriver.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>12</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>86</TopLine>
      <CurrentLine>101</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_GlobalPrototypes.h</PathWithFileName>
      <FilenameWithoutPath>PUB_GlobalPrototypes.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>9</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>95</TopLine>
      <CurrentLine>98</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_IS620N_Config.h</PathWithFileName>
      <FilenameWithoutPath>PUB_IS620N_Config.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>34</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>95</TopLine>
      <CurrentLine>95</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\00_Public\PUB_IS650N_Config.h</PathWithFileName>
      <FilenameWithoutPath>PUB_IS650N_Config.h</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>10_MTR_System</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>25</TopLine>
      <CurrentLine>39</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\10_MTR_System\MTR_FUNCInterface.c</PathWithFileName>
      <FilenameWithoutPath>MTR_FUNCInterface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>300</TopLine>
      <CurrentLine>315</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\10_MTR_System\MTR_Global_Filter.c</PathWithFileName>
      <FilenameWithoutPath>MTR_Global_Filter.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>19</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\10_MTR_System\MTR_GPIODriver_ST.c</PathWithFileName>
      <FilenameWithoutPath>MTR_GPIODriver_ST.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>64</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>10</TopLine>
      <CurrentLine>25</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\10_MTR_System\MTR_InterfaceProcess.c</PathWithFileName>
      <FilenameWithoutPath>MTR_InterfaceProcess.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>37</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>714</TopLine>
      <CurrentLine>729</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\10_MTR_System\MTR_System.c</PathWithFileName>
      <FilenameWithoutPath>MTR_System.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>11_MTR_ReguCtrl</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>912</TopLine>
      <CurrentLine>924</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_FPGAInterface.c</PathWithFileName>
      <FilenameWithoutPath>MTR_FPGAInterface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>32</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1071</TopLine>
      <CurrentLine>1080</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_GetIqRef.c</PathWithFileName>
      <FilenameWithoutPath>MTR_GetIqRef.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>58</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>21</TopLine>
      <CurrentLine>24</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_PDFFCtrl.c</PathWithFileName>
      <FilenameWithoutPath>MTR_PDFFCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>53</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>63</TopLine>
      <CurrentLine>63</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_SpdRegulator.c</PathWithFileName>
      <FilenameWithoutPath>MTR_SpdRegulator.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>28</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>268</TopLine>
      <CurrentLine>268</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_HDH_AbsRomOper.c</PathWithFileName>
      <FilenameWithoutPath>MTR_HDH_AbsRomOper.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>15</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>133</TopLine>
      <CurrentLine>148</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_Tamagawa_AbsRomOper.c</PathWithFileName>
      <FilenameWithoutPath>MTR_Tamagawa_AbsRomOper.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_AbsEncAngleInit.c</PathWithFileName>
      <FilenameWithoutPath>MTR_AbsEncAngleInit.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>329</TopLine>
      <CurrentLine>344</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_AbsRomOper.c</PathWithFileName>
      <FilenameWithoutPath>MTR_AbsRomOper.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>8</TopLine>
      <CurrentLine>23</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_Nikon_AbsRomOper.c</PathWithFileName>
      <FilenameWithoutPath>MTR_Nikon_AbsRomOper.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>504</TopLine>
      <CurrentLine>516</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_PostFPGAErr.c</PathWithFileName>
      <FilenameWithoutPath>MTR_PostFPGAErr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_FPGASync.c</PathWithFileName>
      <FilenameWithoutPath>MTR_FPGASync.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\11_MTR_ReguCtrl\MTR_RDCOper.c</PathWithFileName>
      <FilenameWithoutPath>MTR_RDCOper.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>13_MTR_AuxFunc</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\13_MTR_AuxFunc\MTR_InertiaIdy.c</PathWithFileName>
      <FilenameWithoutPath>MTR_InertiaIdy.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>33</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\13_MTR_AuxFunc\MTR_AngleInit.c</PathWithFileName>
      <FilenameWithoutPath>MTR_AngleInit.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\13_MTR_AuxFunc\MTR_InerFricIden.c</PathWithFileName>
      <FilenameWithoutPath>MTR_InerFricIden.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>20_FUNC_System</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>39</TopLine>
      <CurrentLine>53</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_MTRInterface.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_MTRInterface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_InterfaceProcess.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_InterfaceProcess.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>46</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_Filter.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Filter.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_DMADriver.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_DMADriver.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_GPIODriver.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_GPIODriver.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>52</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>102</TopLine>
      <CurrentLine>117</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\20_FUNC_System\FUNC_System.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_System.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>21_FUNC_SpdToqCtrl</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>60</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>191</TopLine>
      <CurrentLine>205</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\21_FUNC_SpdToqCtrl\FUNC_ToqCtrl.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_ToqCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>61</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>37</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>600</TopLine>
      <CurrentLine>615</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\21_FUNC_SpdToqCtrl\FUNC_SpdCtrl.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_SpdCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\21_FUNC_SpdToqCtrl\FUNC_MultiBlockSpeed.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_MultiBlockSpeed.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>63</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\21_FUNC_SpdToqCtrl\FUNC_GainSwitching.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_GainSwitching.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>22_FUNC_MotionCtrl</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>64</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_EleGear.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_EleGear.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>65</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>964</TopLine>
      <CurrentLine>979</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_Home.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Home.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>66</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_LineInterplt.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_LineInterplt.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>67</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>197</TopLine>
      <CurrentLine>209</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_MultiBlockPos.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_MultiBlockPos.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>68</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_PosCmdFilter.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PosCmdFilter.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>69</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>85</TopLine>
      <CurrentLine>100</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_PosCtrl.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PosCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>70</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>393</TopLine>
      <CurrentLine>407</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_PosRegulator.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PosRegulator.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>71</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>243</TopLine>
      <CurrentLine>258</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_Pulse.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Pulse.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>72</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_XIntPosition.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_XIntPosition.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>73</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>150</TopLine>
      <CurrentLine>162</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_Curve.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Curve.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>74</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>763</TopLine>
      <CurrentLine>775</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_GainRegIndicatrix.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_GainRegIndicatrix.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>75</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>367</TopLine>
      <CurrentLine>379</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_FullCloseLoop.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_FullCloseLoop.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>76</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>35</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>211</TopLine>
      <CurrentLine>235</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\22_FUNC_MotionCtrl\FUNC_PosFbCalc.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PosFbCalc.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>23_FUNC_Monitor1</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>77</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>78</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>926</TopLine>
      <CurrentLine>941</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_ServoMonitor.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_ServoMonitor.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>78</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>306</TopLine>
      <CurrentLine>320</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_StopProcess.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_StopProcess.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>79</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>68</TopLine>
      <CurrentLine>83</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_ServoError.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_ServoError.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>80</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>22</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_DiDo.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_DiDo.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>81</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_VirtualDiDo.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_VirtualDiDo.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>82</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_SpiDriver_ST.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_SpiDriver_ST.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>83</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_AI.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_AI.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>84</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_AoDriver_ST.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_AoDriver_ST.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>85</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>18</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1151</TopLine>
      <CurrentLine>1166</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor\FUNC_ModeSelect.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_ModeSelect.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>23_FUNC_Monitor2</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>86</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_MotorOverLoad.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_MotorOverLoad.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>87</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_OverLoadTable.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_OverLoadTable.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>88</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>16</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_OverLoadProtect.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_OverLoadProtect.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>89</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_TemperaTable.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_TemperaTable.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>90</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_Temperature.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_Temperature.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>91</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_AdcDriver_ST.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_AdcDriver_ST.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>92</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_DCBusVolt.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_DCBusVolt.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>93</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\23_FUNC_Monitor2\FUNC_Monitor_PhaseLack.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Monitor_PhaseLack.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>24_FUNC_VibraDamp_SelfTuning</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>94</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\25_FUNC_VibraDamp_SelfTuning\FUNC_RigidityLevelTable.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_RigidityLevelTable.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>95</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\25_FUNC_VibraDamp_SelfTuning\FUNC_TorqPiTune.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_TorqPiTune.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>96</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\25_FUNC_VibraDamp_SelfTuning\FUNC_FricIdentify.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_FricIdentify.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>97</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>76</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\25_FUNC_VibraDamp_SelfTuning\FUNC_Fft.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Fft.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>98</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\25_FUNC_VibraDamp_SelfTuning\FUNC_FSASpeedCmd.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_FSASpeedCmd.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>25_FUNC_ManageFunCode</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>99</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_CommInterface.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_CommInterface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>100</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>67</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_DriverPara.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_DriverPara.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>101</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>461</TopLine>
      <CurrentLine>473</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_FunCode.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_FunCode.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>102</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>14</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>311</TopLine>
      <CurrentLine>326</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_FunCodeDefault.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_FunCodeDefault.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>103</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_I2cDriver_ST.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_I2cDriver_ST.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>104</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_MotorPara.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_MotorPara.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>105</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>22</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>100</TopLine>
      <CurrentLine>115</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_OperEeprom.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_OperEeprom.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>106</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>13</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>98</TopLine>
      <CurrentLine>109</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_Oscilloscope.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_Oscilloscope.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>107</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_PanelDisplay.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PanelDisplay.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>108</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_PanelKey.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PanelKey.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>109</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_PanelKeyFunArray.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_PanelKeyFunArray.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>110</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\24_FUNC_ManageFunCode\FUNC_ElcLabel.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_ElcLabel.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>30_COMM_Modbus</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>111</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\30_COMM_Modbus\COMM_Modbus.c</PathWithFileName>
      <FilenameWithoutPath>COMM_Modbus.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>112</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>578</TopLine>
      <CurrentLine>593</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\30_COMM_Modbus\COMM_ModbusDrv.c</PathWithFileName>
      <FilenameWithoutPath>COMM_ModbusDrv.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>32_COMM_CANopen</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>113</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>98</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_PV.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_PV.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>114</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>20</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>304</TopLine>
      <CurrentLine>319</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_DeviceCtrl.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_DeviceCtrl.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>115</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1434</TopLine>
      <CurrentLine>1439</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_Home.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_Home.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>116</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_Interface.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_Interface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>117</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>153</TopLine>
      <CurrentLine>165</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_ODT.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_ODT.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>118</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>458</TopLine>
      <CurrentLine>469</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_PP.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_PP.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>119</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>127</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>596</TopLine>
      <CurrentLine>615</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\32_COMM_CANopen\CANopen_Pub.c</PathWithFileName>
      <FilenameWithoutPath>CANopen_Pub.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>33_COMM_ECT</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>120</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_Interface.c</PathWithFileName>
      <FilenameWithoutPath>ECT_Interface.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>121</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>18</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>6</TopLine>
      <CurrentLine>20</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_Pub.c</PathWithFileName>
      <FilenameWithoutPath>ECT_Pub.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>122</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>31</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_ESMDisplay.c</PathWithFileName>
      <FilenameWithoutPath>ECT_ESMDisplay.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>123</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_PP.c</PathWithFileName>
      <FilenameWithoutPath>ECT_PP.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>124</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>537</TopLine>
      <CurrentLine>546</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_PT.c</PathWithFileName>
      <FilenameWithoutPath>ECT_PT.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>125</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>64</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_PV.c</PathWithFileName>
      <FilenameWithoutPath>ECT_PV.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>126</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>125</TopLine>
      <CurrentLine>137</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_CSP.c</PathWithFileName>
      <FilenameWithoutPath>ECT_CSP.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>127</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ECT_Probe.c</PathWithFileName>
      <FilenameWithoutPath>ECT_Probe.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>128</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\coeappl.o</PathWithFileName>
      <FilenameWithoutPath>coeappl.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>129</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\sdoserv.o</PathWithFileName>
      <FilenameWithoutPath>sdoserv.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>130</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\objdef.o</PathWithFileName>
      <FilenameWithoutPath>objdef.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>131</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\mailbox.o</PathWithFileName>
      <FilenameWithoutPath>mailbox.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>132</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ecatuserappl.o</PathWithFileName>
      <FilenameWithoutPath>ecatuserappl.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>133</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ecatslv.o</PathWithFileName>
      <FilenameWithoutPath>ecatslv.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>134</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ecathw.o</PathWithFileName>
      <FilenameWithoutPath>ecathw.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>135</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ecatcoe.o</PathWithFileName>
      <FilenameWithoutPath>ecatcoe.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>136</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\ecatappl.o</PathWithFileName>
      <FilenameWithoutPath>ecatappl.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>137</FileNumber>
      <FileType>3</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\c_comminternal.o</PathWithFileName>
      <FilenameWithoutPath>c_comminternal.o</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>138</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\StmEcatHW.c</PathWithFileName>
      <FilenameWithoutPath>StmEcatHW.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>139</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>59</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\33_COMM_EtherCAT\FUNC_CSPCmdBuffer.c</PathWithFileName>
      <FilenameWithoutPath>FUNC_CSPCmdBuffer.c</FilenameWithoutPath>
    </File>
  </Group>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\11_MTR_ReguCtrl\MTR_GetIqRef.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\PCLint\config\options_A.lnt</PathWithFilename>
    <TopLine>2</TopLine>
    <CurrentLine>20</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\40_STM32F4xx_Lib\inc\core_cm4.h</PathWithFilename>
    <TopLine>170</TopLine>
    <CurrentLine>184</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\23_FUNC_Monitor\FUNC_ModeSelect.h</PathWithFilename>
    <TopLine>38</TopLine>
    <CurrentLine>50</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\22_FUNC_MotionCtrl\FUNC_Curve.h</PathWithFilename>
    <TopLine>24</TopLine>
    <CurrentLine>38</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\24_FUNC_ManageFunCode\FUNC_FunCodeDefault.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\11_MTR_ReguCtrl\MTR_FPGAInterface.h</PathWithFilename>
    <TopLine>229</TopLine>
    <CurrentLine>243</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\23_FUNC_Monitor\FUNC_ServoError.h</PathWithFilename>
    <TopLine>6</TopLine>
    <CurrentLine>21</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\33_COMM_EtherCAT\ECT_CSP.h</PathWithFilename>
    <TopLine>8</TopLine>
    <CurrentLine>23</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\24_FUNC_ManageFunCode\FUNC_AuxFunCode.h</PathWithFilename>
    <TopLine>170</TopLine>
    <CurrentLine>170</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\23_FUNC_Monitor\FUNC_ServoMonitor.h</PathWithFilename>
    <TopLine>86</TopLine>
    <CurrentLine>101</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\20_FUNC_System\FUNC_GlobalVariable.h</PathWithFilename>
    <TopLine>136</TopLine>
    <CurrentLine>142</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\23_FUNC_Monitor\FUNC_ErrorCode.h</PathWithFilename>
    <TopLine>56</TopLine>
    <CurrentLine>70</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\10_MTR_System\MTR_InterfaceProcess.h</PathWithFilename>
    <TopLine>46</TopLine>
    <CurrentLine>61</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\10_MTR_System\MTR_GlobalVariable.h</PathWithFilename>
    <TopLine>77</TopLine>
    <CurrentLine>89</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\21_FUNC_SpdToqCtrl\FUNC_SpdCtrl.h</PathWithFilename>
    <TopLine>41</TopLine>
    <CurrentLine>47</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\24_FUNC_ManageFunCode\FUNC_FunCode.h</PathWithFilename>
    <TopLine>270</TopLine>
    <CurrentLine>270</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\22_FUNC_MotionCtrl\FUNC_PosCtrl.h</PathWithFilename>
    <TopLine>49</TopLine>
    <CurrentLine>49</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\32_COMM_CANopen\CANopen_OD.h</PathWithFilename>
    <TopLine>418</TopLine>
    <CurrentLine>433</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\32_COMM_CANopen\CANopen_PP.h</PathWithFilename>
    <TopLine>57</TopLine>
    <CurrentLine>57</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>E:\work\6软件工程师\1开发项目\620N标准\104版本归档IS620N 201711-201801\代码\620Nv103.5MC710.28\32_COMM_CANopen\CANopen_Pub.h</PathWithFilename>
    <TopLine>109</TopLine>
    <CurrentLine>124</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>1</ActiveTab>
      <Documents>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_PosFbCalc.c</Name>
          <ColumnNumber>35</ColumnNumber>
          <TopLine>211</TopLine>
          <CurrentLine>235</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_Pub.c</Name>
          <ColumnNumber>127</ColumnNumber>
          <TopLine>596</TopLine>
          <CurrentLine>615</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_Oscilloscope.c</Name>
          <ColumnNumber>13</ColumnNumber>
          <TopLine>98</TopLine>
          <CurrentLine>109</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_PP.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>458</TopLine>
          <CurrentLine>469</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_Pub.h</Name>
          <ColumnNumber>2</ColumnNumber>
          <TopLine>109</TopLine>
          <CurrentLine>124</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_PP.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>57</TopLine>
          <CurrentLine>57</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\30_COMM_Modbus\COMM_ModbusDrv.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>578</TopLine>
          <CurrentLine>593</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\30_COMM_Modbus\COMM_Modbus.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ServoMonitor.c</Name>
          <ColumnNumber>78</ColumnNumber>
          <TopLine>926</TopLine>
          <CurrentLine>941</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_OD.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>418</TopLine>
          <CurrentLine>433</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_PosCtrl.h</Name>
          <ColumnNumber>13</ColumnNumber>
          <TopLine>49</TopLine>
          <CurrentLine>49</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_PosCtrl.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>85</TopLine>
          <CurrentLine>100</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_FunCode.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>270</TopLine>
          <CurrentLine>270</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_GlobalPrototypes.h</Name>
          <ColumnNumber>12</ColumnNumber>
          <TopLine>86</TopLine>
          <CurrentLine>101</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\21_FUNC_SpdToqCtrl\FUNC_SpdCtrl.h</Name>
          <ColumnNumber>12</ColumnNumber>
          <TopLine>41</TopLine>
          <CurrentLine>47</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\21_FUNC_SpdToqCtrl\FUNC_SpdCtrl.c</Name>
          <ColumnNumber>37</ColumnNumber>
          <TopLine>600</TopLine>
          <CurrentLine>615</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\20_FUNC_System\FUNC_System.c</Name>
          <ColumnNumber>52</ColumnNumber>
          <TopLine>102</TopLine>
          <CurrentLine>117</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_GlobalVariable.h</Name>
          <ColumnNumber>12</ColumnNumber>
          <TopLine>77</TopLine>
          <CurrentLine>89</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_FUNCInterface.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>25</TopLine>
          <CurrentLine>39</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_InterfaceProcess.h</Name>
          <ColumnNumber>14</ColumnNumber>
          <TopLine>46</TopLine>
          <CurrentLine>61</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ErrorCode.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>56</TopLine>
          <CurrentLine>70</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\20_FUNC_System\FUNC_GlobalVariable.h</Name>
          <ColumnNumber>12</ColumnNumber>
          <TopLine>136</TopLine>
          <CurrentLine>142</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ModeSelect.c</Name>
          <ColumnNumber>18</ColumnNumber>
          <TopLine>1151</TopLine>
          <CurrentLine>1166</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_StopProcess.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>306</TopLine>
          <CurrentLine>320</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ServoMonitor.h</Name>
          <ColumnNumber>15</ColumnNumber>
          <TopLine>86</TopLine>
          <CurrentLine>101</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_System.c</Name>
          <ColumnNumber>37</ColumnNumber>
          <TopLine>714</TopLine>
          <CurrentLine>729</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_AbsRomOper.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>329</TopLine>
          <CurrentLine>344</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ServoError.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>68</TopLine>
          <CurrentLine>83</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_Tamagawa_AbsRomOper.c</Name>
          <ColumnNumber>15</ColumnNumber>
          <TopLine>133</TopLine>
          <CurrentLine>148</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_HDH_AbsRomOper.c</Name>
          <ColumnNumber>28</ColumnNumber>
          <TopLine>268</TopLine>
          <CurrentLine>268</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_AuxFunCode.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>170</TopLine>
          <CurrentLine>170</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_Table.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>360</TopLine>
          <CurrentLine>375</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_FunCode.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>461</TopLine>
          <CurrentLine>473</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_OperEeprom.c</Name>
          <ColumnNumber>22</ColumnNumber>
          <TopLine>100</TopLine>
          <CurrentLine>115</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_Home.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1434</TopLine>
          <CurrentLine>1439</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_MultiBlockPos.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>197</TopLine>
          <CurrentLine>209</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_Home.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>964</TopLine>
          <CurrentLine>979</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_FullCloseLoop.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>367</TopLine>
          <CurrentLine>379</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_DeviceCtrl.c</Name>
          <ColumnNumber>20</ColumnNumber>
          <TopLine>304</TopLine>
          <CurrentLine>319</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\33_COMM_EtherCAT\ECT_CSP.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>125</TopLine>
          <CurrentLine>137</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\32_COMM_CANopen\CANopen_ODT.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>153</TopLine>
          <CurrentLine>165</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_PostFPGAErr.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>504</TopLine>
          <CurrentLine>516</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_Nikon_AbsRomOper.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>8</TopLine>
          <CurrentLine>23</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_IS620N_Config.h</Name>
          <ColumnNumber>9</ColumnNumber>
          <TopLine>95</TopLine>
          <CurrentLine>98</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_FunCodeDefault.c</Name>
          <ColumnNumber>14</ColumnNumber>
          <TopLine>311</TopLine>
          <CurrentLine>326</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\33_COMM_EtherCAT\ECT_CSP.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>8</TopLine>
          <CurrentLine>23</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_Pulse.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>243</TopLine>
          <CurrentLine>258</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ServoError.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>6</TopLine>
          <CurrentLine>21</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_Global_Filter.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>300</TopLine>
          <CurrentLine>315</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_PosRegulator.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>393</TopLine>
          <CurrentLine>407</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_FPGAInterface.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>229</TopLine>
          <CurrentLine>243</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\33_COMM_EtherCAT\ECT_Pub.c</Name>
          <ColumnNumber>18</ColumnNumber>
          <TopLine>6</TopLine>
          <CurrentLine>20</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_FPGAInterface.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>912</TopLine>
          <CurrentLine>924</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\24_FUNC_ManageFunCode\FUNC_FunCodeDefault.h</Name>
          <ColumnNumber>130</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_GainRegIndicatrix.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>763</TopLine>
          <CurrentLine>775</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_Curve.h</Name>
          <ColumnNumber>10</ColumnNumber>
          <TopLine>24</TopLine>
          <CurrentLine>38</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\22_FUNC_MotionCtrl\FUNC_Curve.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>150</TopLine>
          <CurrentLine>162</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\23_FUNC_Monitor\FUNC_ModeSelect.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>38</TopLine>
          <CurrentLine>50</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\40_STM32F4xx_Lib\src\stm32f4xx_dma2d.c</Name>
          <ColumnNumber>39</ColumnNumber>
          <TopLine>139</TopLine>
          <CurrentLine>139</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\40_STM32F4xx_Lib\src\stm32f4xx_can.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\\40_STM32F4xx_Lib\inc\core_cm4.h</Name>
          <ColumnNumber>21</ColumnNumber>
          <TopLine>170</TopLine>
          <CurrentLine>184</CurrentLine>
        </Doc>
        <Doc>
          <Name>D:\PCLint\config\options_A.lnt</Name>
          <ColumnNumber>15</ColumnNumber>
          <TopLine>2</TopLine>
          <CurrentLine>20</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_IS650N_Config.h</Name>
          <ColumnNumber>34</ColumnNumber>
          <TopLine>95</TopLine>
          <CurrentLine>95</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_RCCDriver.c</Name>
          <ColumnNumber>25</ColumnNumber>
          <TopLine>6</TopLine>
          <CurrentLine>20</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\00_Public\PUB_Main.c</Name>
          <ColumnNumber>39</ColumnNumber>
          <TopLine>193</TopLine>
          <CurrentLine>202</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\40_STM32F4xx_Lib\startup_stm32f4xx.s</Name>
          <ColumnNumber>15</ColumnNumber>
          <TopLine>52</TopLine>
          <CurrentLine>52</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\33_COMM_EtherCAT\ECT_PT.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>537</TopLine>
          <CurrentLine>546</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_GetIqRef.h</Name>
          <ColumnNumber>12</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_GetIqRef.c</Name>
          <ColumnNumber>32</ColumnNumber>
          <TopLine>1071</TopLine>
          <CurrentLine>1080</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\21_FUNC_SpdToqCtrl\FUNC_ToqCtrl.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>191</TopLine>
          <CurrentLine>205</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\20_FUNC_System\FUNC_MTRInterface.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>39</TopLine>
          <CurrentLine>53</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_SpdRegulator.c</Name>
          <ColumnNumber>53</ColumnNumber>
          <TopLine>63</TopLine>
          <CurrentLine>63</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\11_MTR_ReguCtrl\MTR_PDFFCtrl.c</Name>
          <ColumnNumber>58</ColumnNumber>
          <TopLine>21</TopLine>
          <CurrentLine>24</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\10_MTR_System\MTR_InterfaceProcess.c</Name>
          <ColumnNumber>64</ColumnNumber>
          <TopLine>10</TopLine>
          <CurrentLine>25</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
