# Keil uVision project SERVOSW_G2.uvproj, settings and files
target IS620 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: IS620N +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: __CC_ARM
  c include: ..\00_Public;..\10_MTR_System;..\11_MTR_ReguCtrl;..\12_MTR_Monitor;..\20_FUNC_System;..\21_FUNC_SpdToqCtrl;..\22_FUNC_MotionCtrl;..\23_FUNC_Monitor;..\24_FUNC_ManageFunCode;..\25_FUNC_VibraDamp_SelfTuning;..\30_COMM_Modbus;..\\40_STM32F4xx_Lib\inc;..\13_MTR_AuxFunc;..\10_MTR_Obj;..\22_FUNC_MotionCtrl_Obj;..\23_FUNC_Monitor2;..\32_COMM_CANopen;..\33_COMM_EtherCAT
  memory RVCT4: ROM 0x800c200 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../40_STM32F4xx_Lib/: startup_stm32f4xx.s
  group STM32F4xx_Lib
    ../40_STM32F4xx_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 00_Public
    ../00_Public/: PUB_Main.c PUB_Table.c PUB_RCCDriver.c PUB_GlobalPrototypes.h PUB_IS620N_Config.h PUB_IS650N_Config.h
  group 10_MTR_System
    ../10_MTR_System/: MTR_FUNCInterface.c MTR_Global_Filter.c MTR_GPIODriver_ST.c MTR_InterfaceProcess.c MTR_System.c
  group 11_MTR_ReguCtrl
    ../11_MTR_ReguCtrl/: MTR_FPGAInterface.c MTR_GetIqRef.c MTR_PDFFCtrl.c MTR_SpdRegulator.c MTR_HDH_AbsRomOper.c MTR_Tamagawa_AbsRomOper.c MTR_AbsEncAngleInit.c MTR_AbsRomOper.c MTR_Nikon_AbsRomOper.c MTR_PostFPGAErr.c MTR_FPGASync.c MTR_RDCOper.c
  group 13_MTR_AuxFunc
    ../13_MTR_AuxFunc/: MTR_InertiaIdy.c MTR_AngleInit.c MTR_InerFricIden.c
  group 20_FUNC_System
    ../20_FUNC_System/: FUNC_MTRInterface.c FUNC_InterfaceProcess.c FUNC_Filter.c FUNC_DMADriver.c FUNC_GPIODriver.c FUNC_System.c
  group 21_FUNC_SpdToqCtrl
    ../21_FUNC_SpdToqCtrl/: FUNC_ToqCtrl.c FUNC_SpdCtrl.c FUNC_MultiBlockSpeed.c FUNC_GainSwitching.c
  group 22_FUNC_MotionCtrl
    ../22_FUNC_MotionCtrl/: FUNC_EleGear.c FUNC_Home.c FUNC_LineInterplt.c FUNC_MultiBlockPos.c FUNC_PosCmdFilter.c FUNC_PosCtrl.c FUNC_PosRegulator.c FUNC_Pulse.c FUNC_XIntPosition.c FUNC_Curve.c FUNC_GainRegIndicatrix.c FUNC_FullCloseLoop.c FUNC_PosFbCalc.c
  group 23_FUNC_Monitor1
    ../23_FUNC_Monitor/: FUNC_ServoMonitor.c FUNC_StopProcess.c FUNC_ServoError.c FUNC_DiDo.c FUNC_VirtualDiDo.c FUNC_SpiDriver_ST.c FUNC_AI.c FUNC_AoDriver_ST.c FUNC_ModeSelect.c
  group 23_FUNC_Monitor2
    ../23_FUNC_Monitor2/: FUNC_MotorOverLoad.c FUNC_Monitor_OverLoadTable.c FUNC_Monitor_OverLoadProtect.c FUNC_Monitor_TemperaTable.c FUNC_Monitor_Temperature.c FUNC_AdcDriver_ST.c FUNC_Monitor_DCBusVolt.c FUNC_Monitor_PhaseLack.c
  group 24_FUNC_VibraDamp_SelfTuning
    ../25_FUNC_VibraDamp_SelfTuning/: FUNC_RigidityLevelTable.c FUNC_TorqPiTune.c FUNC_FricIdentify.c FUNC_Fft.c FUNC_FSASpeedCmd.c
  group 25_FUNC_ManageFunCode
    ../24_FUNC_ManageFunCode/: FUNC_CommInterface.c FUNC_DriverPara.c FUNC_FunCode.c FUNC_FunCodeDefault.c FUNC_I2cDriver_ST.c FUNC_MotorPara.c FUNC_OperEeprom.c FUNC_Oscilloscope.c FUNC_PanelDisplay.c FUNC_PanelKey.c FUNC_PanelKeyFunArray.c FUNC_ElcLabel.c
  group 30_COMM_Modbus
    ../30_COMM_Modbus/: COMM_Modbus.c COMM_ModbusDrv.c
  group 32_COMM_CANopen
    ../32_COMM_CANopen/: CANopen_PV.c CANopen_DeviceCtrl.c CANopen_Home.c CANopen_Interface.c CANopen_ODT.c CANopen_PP.c CANopen_Pub.c
  group 33_COMM_ECT
    ../33_COMM_EtherCAT/: ECT_Interface.c ECT_Pub.c ECT_ESMDisplay.c ECT_PP.c ECT_PT.c ECT_PV.c ECT_CSP.c ECT_Probe.c coeappl.o sdoserv.o objdef.o mailbox.o ecatuserappl.o ecatslv.o ecathw.o ecatcoe.o ecatappl.o c_comminternal.o StmEcatHW.c FUNC_CSPCmdBuffer.c
